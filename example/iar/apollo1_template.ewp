# IAR project apollo1_template.ewp, settings and files
configuration APOLLO512-KCR_Release (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: APOLLO_512=1; APOLLO_512=1
  ICCARM.CCIncludePath2: ..\..\common; ..\..\example\source; ..\..\example\source\config; ..\..\library; ..\..\library\highlevel; ..\..\library\middleware; ..\..\library\lowlevel
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: apollo1_template.srec
  ILINK.IlinkOutputFile: apollo1_template.out
  ILINK.IlinkIcfFile: config\apollo512-kcr_rom.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration APOLLO512-KCR_Debug (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MB9BF566R Spansion MB9BF566R
  ILINK.IlinkIcfFile: config\apollo512-kcr_ram.icf
configuration APOLLO512-KBR_Release (ARM, debug)
  as the first configuration, except:
  ILINK.IlinkIcfFile: config\apollo512-kbr_rom.icf
configuration APOLLO512-KBR_Debug (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MB9BF566R Spansion MB9BF566R
  ILINK.IlinkIcfFile: config\apollo512-kbr_ram.icf
configuration APOLLO256-KCR_Release (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: APOLLO_256=1; APOLLO_256=1
  ILINK.IlinkIcfFile: config\apollo256-kcr_rom.icf
configuration APOLLO256-KCR_Debug (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MB9BF566R Spansion MB9BF566R
  ICCARM.CCDefines: APOLLO_256=1; APOLLO_256=1
  ILINK.IlinkIcfFile: config\apollo256-kcr_ram.icf
configuration APOLLO256-KBR_Release (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: APOLLO_256=1; APOLLO_256=1
  ILINK.IlinkIcfFile: config\apollo256-kbr_rom.icf
configuration APOLLO256-KBR_Debug (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MB9BF566R Spansion MB9BF566R
  ICCARM.CCDefines: APOLLO_256=1; APOLLO_256=1
  ILINK.IlinkIcfFile: config\apollo256-kbr_ram.icf
  group (top)
    ../../: Readme.txt
  group common
    ../../common/: system_apollo1.c
  group source
    ../source/: main.c
    ./: startup_apollo1.s
