# Keil uVision project apollo1_template.uvprojx, settings and files
target APOLLO512-KCR_Debug (ARM-ADS)
  device: ARMCM4_FP ARM
  cpu: IROM(0x0,0x80000) IRAM1(0x10000000,0x10000) CPUTYPE"(Cortex-M4")
  output: apollo1_template +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: APOLLO_512=1 APOLLO_512=1 APOLLO_512=1 APOLLO_512=1
  c include: ..\..\common;..\..\example\source;..\..\example\source\config;..\..\library;..\..\library\lowlevel;..\..\library\middleware;..\..\library\highlevel
  memory RVCT4: ROM 0x10000000 size 0x8000
  memory RVCT9: RAM 0x10008000 size 0x8000
  group common
    ../../common/: system_apollo1.c
  group source
    ../source/: main.c
    ../../: Readme.txt
    ./: startup_apollo1.s
target APOLLO512-KCR_Release (ARM-ADS)
  device: ARMCM4_FP ARM
  cpu: as above
  output: apollo1_template +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: APOLLO_512=1 APOLLO_512=1
  c include: as above
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x10000
target APOLLO512-KBR_Debug (ARM-ADS)
  device: ARMCM4_FP ARM
  cpu: as above
  output: apollo1_template +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: APOLLO_512=1 APOLLO_512=1 APOLLO_512=1 APOLLO_512=1
  c include: as above
  memory RVCT4: ROM 0x10000000 size 0x8000
  memory RVCT9: RAM 0x10008000 size 0x8000
target APOLLO512-KBR_Release (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: APOLLO512-KCR Ambiq Micro
  pack: AmbiqMicro.Apollo_DFP.1.0.0
  cpu: IRAM(0x10000000,0x10000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: apollo1_template +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: APOLLO_512=1 APOLLO_512=1
  c include: as above
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x10000
target APOLLO256-KCR_Debug (ARM-ADS)
  device: ARMCM4_FP ARM
  cpu: IROM(0x0,0x40000) IRAM1(0x10000000,0x8000) CPUTYPE"(Cortex-M4")
  output: apollo1_template +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: APOLLO_256=1 APOLLO_256=1 APOLLO_256=1 APOLLO_256=1
  c include: as above
  memory RVCT4: ROM 0x10000000 size 0x4000
  memory RVCT9: RAM 0x10004000 size 0x4000
target APOLLO256-KCR_Release (ARM-ADS)
  device: ARMCM4_FP ARM
  cpu: as above
  output: apollo1_template +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: APOLLO_256=1 APOLLO_256=1
  c include: as above
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x10000000 size 0x8000
target APOLLO256-KBR_Debug (ARM-ADS)
  device: ARMCM4_FP ARM
  cpu: as above
  output: apollo1_template +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: APOLLO_256=1 APOLLO_256=1 APOLLO_256=1 APOLLO_256=1
  c include: as above
  memory RVCT4: ROM 0x10000000 size 0x4000
  memory RVCT9: RAM 0x10004000 size 0x4000
target APOLLO256-KBR_Release (ARM-ADS)
  device: ARMCM4_FP ARM
  cpu: as above
  output: apollo1_template +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: APOLLO_256=1 APOLLO_256=1
  c include: as above
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x10000000 size 0x8000
